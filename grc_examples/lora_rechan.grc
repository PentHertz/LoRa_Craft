options:
  parameters:
    author: FlUxIuS
    generate_options: hb
    id: lora_rechan
    output_language: python
    title: Recenter LoRa chans
  states: {}

blocks:
- name: twidth
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: htd_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: cutoff
  id: parameter
  parameters:
    value: 75e3
  states: {}
- name: decim
  id: parameter
  parameters:
    value: '1'
  states: {}
- name: htd_offset
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: twidth
    win: firdes.WIN_HAMMING
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '70'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '0']
- [low_pass_filter_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
