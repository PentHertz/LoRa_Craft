options:
  parameters:
    author: FlUxIuS
    copyright: PentHertz
    description: Example of a schema that receive LoRa frames and write to an UDP socket to be decoded with the Scapy Layer
    generate_options: qt_gui
    id: LoRa_multiSF
    output_language: python
    title: LoRa Receiver to UDP socket
  states: {}

blocks:
- name: cutoff
  id: variable
  parameters:
    value: 75e3*2
  states: {}
- name: decim
  id: variable
  parameters:
    value: (samp_rate/125e3)/4
  states: {}
- name: freq
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '10'
    type: complex
  states: {}
- name: lora_rechan_0
  id: lora_rechan
  parameters:
    cutoff: cutoff
    decim: decim
    htd_offset: '-100e3'
    samp_rate: samp_rate
  states: {}
- name: lora_rechan_0_0
  id: lora_rechan
  parameters:
    cutoff: cutoff
    decim: decim
    htd_offset: '-300e3'
    samp_rate: samp_rate
  states: {}
- name: lora_rechan_0_0_0
  id: lora_rechan
  parameters:
    cutoff: cutoff
    decim: decim
    htd_offset: '-500e3'
    samp_rate: samp_rate
  states: {}
- name: lora_rechan_0_0_0_0
  id: lora_rechan
  parameters:
    cutoff: cutoff
    decim: decim
    htd_offset: '-900e3'
    samp_rate: samp_rate
  states: {}
- name: lora_rechan_0_0_0_0_0
  id: lora_rechan
  parameters:
    cutoff: cutoff
    decim: decim
    htd_offset: '-700e3'
    samp_rate: samp_rate
  states: {}
- name: lora_rechan_0_0_0_0_0_0
  id: lora_rechan
  parameters:
    cutoff: cutoff
    decim: decim
    htd_offset: 700e3
    samp_rate: samp_rate
  states: {}
- name: lora_rechan_0_0_0_0_1
  id: lora_rechan
  parameters:
    cutoff: cutoff
    decim: decim
    htd_offset: 900e3
    samp_rate: samp_rate
  states: {}
- name: lora_rechan_0_0_0_1
  id: lora_rechan
  parameters:
    cutoff: cutoff
    decim: decim
    htd_offset: 500e3
    samp_rate: samp_rate
  states: {}
- name: lora_rechan_0_0_1
  id: lora_rechan
  parameters:
    cutoff: cutoff
    decim: decim
    htd_offset: 300e3
    samp_rate: samp_rate
  states: {}
- name: lora_rechan_0_1
  id: lora_rechan
  parameters:
    cutoff: cutoff
    decim: decim
    htd_offset: 100e3
    samp_rate: samp_rate
  states: {}
- name: lora_txrxdecode_0
  id: lora_txrxdecode
  parameters:
    bandw: 125e3
    samp_rate: samp_rate/decim
    spreadf: '7'
  states: {}
- name: lora_txrxdecode_0_0
  id: lora_txrxdecode
  parameters:
    bandw: 125e3
    samp_rate: samp_rate/decim
    spreadf: '9'
  states: {}
- name: lora_txrxdecode_0_0_0
  id: lora_txrxdecode
  parameters:
    bandw: 125e3
    samp_rate: samp_rate/decim
    spreadf: '8'
  states: {}
- name: lora_txrxdecode_0_0_1
  id: lora_txrxdecode
  parameters:
    bandw: 125e3
    samp_rate: samp_rate/decim
    spreadf: '10'
  states: {}
- name: lora_txrxdecode_0_0_1_0
  id: lora_txrxdecode
  parameters:
    bandw: 125e3
    samp_rate: samp_rate/decim
    spreadf: '11'
  states: {}
- name: lora_txrxdecode_0_0_1_0_0
  id: lora_txrxdecode
  parameters:
    bandw: 125e3
    samp_rate: samp_rate/decim
    spreadf: '12'
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_add_xx_0, '0', lora_txrxdecode_0, '0']
- [blocks_add_xx_0, '0', lora_txrxdecode_0_0, '0']
- [blocks_add_xx_0, '0', lora_txrxdecode_0_0_0, '0']
- [blocks_add_xx_0, '0', lora_txrxdecode_0_0_1, '0']
- [blocks_add_xx_0, '0', lora_txrxdecode_0_0_1_0, '0']
- [blocks_add_xx_0, '0', lora_txrxdecode_0_0_1_0_0, '0']
- [lora_rechan_0, '0', blocks_add_xx_0, '0']
- [lora_rechan_0_0, '0', blocks_add_xx_0, '1']
- [lora_rechan_0_0_0, '0', blocks_add_xx_0, '2']
- [lora_rechan_0_0_0_0, '0', blocks_add_xx_0, '3']
- [lora_rechan_0_0_0_0_0, '0', blocks_add_xx_0, '4']
- [lora_rechan_0_0_0_0_0_0, '0', blocks_add_xx_0, '7']
- [lora_rechan_0_0_0_0_1, '0', blocks_add_xx_0, '6']
- [lora_rechan_0_0_0_1, '0', blocks_add_xx_0, '8']
- [lora_rechan_0_0_1, '0', blocks_add_xx_0, '5']
- [lora_rechan_0_1, '0', blocks_add_xx_0, '9']
- [osmosdr_source_1, '0', lora_rechan_0, '0']
- [osmosdr_source_1, '0', lora_rechan_0_0, '0']
- [osmosdr_source_1, '0', lora_rechan_0_0_0, '0']
- [osmosdr_source_1, '0', lora_rechan_0_0_0_0, '0']
- [osmosdr_source_1, '0', lora_rechan_0_0_0_0_0, '0']
- [osmosdr_source_1, '0', lora_rechan_0_0_0_0_0_0, '0']
- [osmosdr_source_1, '0', lora_rechan_0_0_0_0_1, '0']
- [osmosdr_source_1, '0', lora_rechan_0_0_0_1, '0']
- [osmosdr_source_1, '0', lora_rechan_0_0_1, '0']
- [osmosdr_source_1, '0', lora_rechan_0_1, '0']
- [osmosdr_source_1, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_1, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
