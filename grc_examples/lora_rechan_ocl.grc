options:
  parameters:
    author: FlUxIuS
    generate_options: hb
    id: lora_rechan_ocl
    output_language: python
    title: Recenter LoRa chans OpenOCL
  states: {}

blocks:
- name: twidth
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: htd_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: clenabled_clLowPassFilter_0
  id: clenabled_clLowPassFilter
  parameters:
    beta: '6.76'
    cutoff_freq: cutoff
    decimation: decim
    deviceId: '0'
    devices: '1'
    gain: '1'
    openCLPlatform: '1'
    platformId: '0'
    samp_rate: samp_rate
    setDebug: '0'
    use_time: 'True'
    width: twidth
    win: firdes.WIN_HAMMING
  states: {}
- name: clenabled_clMultiply_0
  id: clenabled_clMultiply
  parameters:
    deviceId: '0'
    devices: '1'
    openCLPlatform: '1'
    platformId: '0'
    setDebug: '0'
    type: complex
  states: {}
- name: cutoff
  id: parameter
  parameters:
    value: 75e3
  states: {}
- name: decim
  id: parameter
  parameters:
    value: '1'
  states: {}
- name: htd_offset
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '70'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', clenabled_clMultiply_0, '0']
- [clenabled_clLowPassFilter_0, '0', pad_sink_0, '0']
- [clenabled_clMultiply_0, '0', clenabled_clLowPassFilter_0, '0']
- [pad_source_0, '0', clenabled_clMultiply_0, '1']

metadata:
  file_format: 1
