options:
  parameters:
    author: FlUxIuS
    copyright: PentHertz
    description: Example of a schema that receive LoRa frames and write to an UDP socket to be decoded with the Scapy Layer
    generate_options: qt_gui
    id: LoRa_usrp_receive_to_UDP
    output_language: python
    title: LoRa Receiver to UDP socket with USRP
  states: {}

blocks:
- name: channel_freq
  id: variable_qtgui_entry
  parameters:
    label: Channel frequency
    type: real
    value: 868.2e6
  states: {}
- name: freq_slider
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: 867e6
    step: '1'
    stop: 869e6
    value: 868e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: lora_lora_receiver_0
  id: lora_lora_receiver
  parameters:
    bandwidth: '125000'
    center_freq: 868e6
    channel_list: channel_freq
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '7'
  states: {}
- name: lora_message_socket_sink_0
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '0'
    port: '40868'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq_slider
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: channel_freq
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate
    center_freq0: freq_slider
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [lora_lora_receiver_0, frames, lora_message_socket_sink_0, in]
- [uhd_usrp_source_0, '0', lora_lora_receiver_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
