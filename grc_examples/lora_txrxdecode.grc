options:
  parameters:
    author: FlUxIuS
    generate_options: hb
    id: lora_txrxdecode
    output_language: python
    title: LoRa TXRX decode
  states: {}

blocks:
- name: bandw
  id: parameter
  parameters:
    value: 125e3
  states: {}
- name: lora_lora_receiver_0
  id: lora_lora_receiver
  parameters:
    bandwidth: int(bandw)
    center_freq: 868e6
    channel_list: 868e6
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreadf
  states: {}
- name: lora_lora_receiver_0_0
  id: lora_lora_receiver
  parameters:
    bandwidth: int(bandw)
    center_freq: 868e6
    channel_list: 868e6
    conj: 'True'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreadf
  states: {}
- name: lora_message_socket_sink_0
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '1'
    port: '40868'
  states: {}
- name: lora_message_socket_sink_0_0
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '1'
    port: '40868'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: 2e6
  states: {}
- name: spreadf
  id: parameter
  parameters:
    value: '7'
  states: {}

connections:
- [lora_lora_receiver_0, frames, lora_message_socket_sink_0, in]
- [lora_lora_receiver_0_0, frames, lora_message_socket_sink_0_0, in]
- [pad_source_0, '0', lora_lora_receiver_0, '0']
- [pad_source_0, '0', lora_lora_receiver_0_0, '0']

metadata:
  file_format: 1
